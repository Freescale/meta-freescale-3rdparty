require linux-lx2160acex7.inc
