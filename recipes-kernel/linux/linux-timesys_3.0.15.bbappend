# Copyright (C) 2013-2014 Timesys Corporation
# Released under the MIT license (see COPYING.MIT for the terms)

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

SRCBRANCH_pcl052 = "3.0-pcl052"
SRCREV_pcl052 = "655f7949b5fd0b66bde03fc3c63c7a436353b1e1"
SRCBRANCH_pcm052 = "3.0-pcm052"
SRCREV_pcm052 = "7a27fd26d2b5b732e12ecea13a846679cbafe9a9"
