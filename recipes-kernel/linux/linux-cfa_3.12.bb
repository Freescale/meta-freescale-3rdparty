require linux-cfa.inc

SRCBRANCH = "cfa-3.12.6"
SRCREV = "f52fac6b3656c8833690efae7e2e688e8d4105c2"

COMPATIBLE_MACHINE = "cfa10036"
