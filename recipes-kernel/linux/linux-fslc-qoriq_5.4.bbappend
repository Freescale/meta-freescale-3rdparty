FILESEXTRAPATHS:append:lx2160acex7 := "${THISDIR}/linux-fslc-qoriq-lx2160acex7:"

require linux-lx2160acex7.inc
