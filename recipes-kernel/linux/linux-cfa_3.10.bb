require linux-cfa.inc

SRCBRANCH = "cfa-3.10.25"
SRCREV = "61dbe8ef338ce4cc1c10d5a6cdd418c047fb136d"

COMPATIBLE_MACHINE = "cfa10036"

