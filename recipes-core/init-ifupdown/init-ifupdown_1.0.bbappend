FILESEXTRAPATHS:prepend:imx233-olinuxino-maxi := "${THISDIR}/init-ifupdown:"
