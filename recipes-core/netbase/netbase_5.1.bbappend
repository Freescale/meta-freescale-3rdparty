FILESEXTRAPATHS_prepend := "${THISDIR}/netbase:"
