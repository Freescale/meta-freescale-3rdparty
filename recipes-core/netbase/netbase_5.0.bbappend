FILESEXTRAPATHS_prepend := "${THISDIR}/netbase:"

PRINC := "${@int(PRINC) + 1}"
