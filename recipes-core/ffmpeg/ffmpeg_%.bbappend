EXTRA_OECONF_append_mx23 = " --extra-libs=-latomic"
