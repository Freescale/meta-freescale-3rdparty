DESCRIPTION = "Nvram support for Broadcom 43430 wifi/bt device"
SECTION = "kernel"

require broadcom-nvram-config.inc

CHIP_MODEL = "43430"

COMPATIBLE_MACHINE = "(imx7s-warp)"
