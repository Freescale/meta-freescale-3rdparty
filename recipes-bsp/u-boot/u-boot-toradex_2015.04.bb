include u-boot-toradex.inc

PV = "v2015.04+git${SRCPV}"

SRCREV = "06ee8db6422e02337242e43b8573359443db59ea"
SRCBRANCH = "2015.04-toradex"
COMPATIBLE_MACHINE = "(vf)"
