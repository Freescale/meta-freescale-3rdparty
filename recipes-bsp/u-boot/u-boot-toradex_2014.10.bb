include u-boot-toradex.inc

PV = "v2014.10+git${SRCPV}"

SRCREV = "73b99ed96be527c482e63f8d0aac4e6188b1f7e0"
SRCBRANCH = "2014.10-toradex"
COMPATIBLE_MACHINE = "(vf)"
